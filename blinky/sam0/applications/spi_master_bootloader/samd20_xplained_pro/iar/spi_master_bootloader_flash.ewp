# IAR project spi_master_bootloader_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD20J18 Atmel ATSAMD20J18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SPI_CALLBACK_MODE=true; ARM_MATH_CM0=true; __SAMD20J18__; WDT_CALLBACK_MODE=true; BOARD=SAMD20_XPLAINED_PRO
  ICCARM.CCIncludePath2: ../../../../drivers/system/clock/clock_samd20; ../../../../drivers/system/power; ../../../../drivers/system/reset; ../../../../utils/preprocessor; ../../../../boards/samd20_xplained_pro; ../../../../utils/cmsis/samd20/source; ../../../../drivers/sercom/spi; ../../../../drivers/nvm; ../../../../drivers/sercom; ../../../../drivers/port; ../../../../boards; ../../../../drivers/wdt; ../../../../utils; ../../../../../common2/components/memory/data_flash/at45dbx; ../../../../../common/utils; ../../../../drivers/system/interrupt/system_interrupt_samd20; ../../../../drivers/system/interrupt; ../../../../drivers/system/power/power_sam_d_r; ../../../../drivers/system/reset/reset_sam_d_r; ../..; ../../../../../common/boards; ../../../../utils/cmsis/samd20/include; ../../../../drivers/system/pinmux; ../../../../drivers/system; ..; ../../../../utils/header_files; ../../../../drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: spi_master_bootloader_flash.bin
  ILINK.IlinkOutputFile: spi_master_bootloader_flash.out
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/samd20/iar/samd20j18_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common2/components/memory/data_flash/at45dbx
    ../../../../../common2/components/memory/data_flash/at45dbx/: at45dbx.c at45dbx.h at45dbx_hal_spi.h
  group sam0/boards/samd20_xplained_pro
    ../../../../boards/samd20_xplained_pro/: board_init.c samd20_xplained_pro.h
  group sam0/drivers/system
    ../../../../drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd20
    ../../../../drivers/system/clock/clock_samd20/: clock.c gclk.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/interrupt
    ../../../../drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd20
    ../../../../drivers/system/interrupt/system_interrupt_samd20/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/reset/reset_sam_d_r
    ../../../../drivers/system/reset/reset_sam_d_r/: reset.h
  group sam0/drivers/system/power/power_sam_d_r
    ../../../../drivers/system/power/power_sam_d_r/: power.h
  group sam0/drivers/port
    ../../../../drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/wdt
    ../../../../drivers/wdt/: wdt_callback.c wdt.c wdt_callback.h wdt.h
  group sam0/drivers/wdt/quick_start
    ../../../../drivers/wdt/quick_start/: qs_wdt_basic.h
  group sam0/drivers/wdt/quick_start_callback
    ../../../../drivers/wdt/quick_start_callback/: qs_wdt_callback.h
  group sam0/drivers/sercom
    ../../../../drivers/sercom/: sercom.c sercom_interrupt.c sercom.h sercom_pinout.h sercom_interrupt.h
  group sam0/drivers/sercom/spi
    ../../../../drivers/sercom/spi/: spi.c spi_interrupt.c spi_interrupt.h spi.h
  group sam0/drivers/sercom/spi/quick_start_slave
    ../../../../drivers/sercom/spi/quick_start_slave/: qs_spi_slave_basic.h
  group sam0/drivers/sercom/spi/quick_start_master
    ../../../../drivers/sercom/spi/quick_start_master/: qs_spi_master_basic.h
  group sam0/drivers/sercom/spi/quick_start_dma
    ../../../../drivers/sercom/spi/quick_start_dma/: qs_spi_dma_use.h
  group sam0/drivers/sercom/spi/quick_start_slave_callback
    ../../../../drivers/sercom/spi/quick_start_slave_callback/: qs_spi_slave_callback.h
  group sam0/drivers/sercom/spi/quick_start_master_callback
    ../../../../drivers/sercom/spi/quick_start_master_callback/: qs_spi_master_callback.h
  group sam0/drivers/nvm
    ../../../../drivers/nvm/: nvm.c nvm.h
  group sam0/drivers/nvm/quick_start_basic
    ../../../../drivers/nvm/quick_start_basic/: qs_nvm_basic.h
  group sam0/utils
    ../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samd20/source
    ../../../../utils/cmsis/samd20/source/: system_samd20.c system_samd20.h
  group sam0/utils/cmsis/samd20/source/iar
    ../../../../utils/cmsis/samd20/source/iar/: startup_samd20.c
  group sam0/utils/cmsis/samd20/include
    ../../../../utils/cmsis/samd20/include/: samd20j14.h samd20j16.h samd20e14.h samd20g18.h samd20g17.h samd20e18.h samd20e16.h samd20e15.h samd20j18.h samd20g16.h samd20g14.h samd20e17.h samd20j15.h samd20j17.h samd20g17u.h samd20.h samd20g18u.h samd20g15.h
  group sam0/utils/cmsis/samd20/include/instance
    ../../../../utils/cmsis/samd20/include/instance/: evsys.h tc1.h pac0.h tc2.h eic.h sercom2.h pac2.h sercom1.h dac.h rtc.h ac.h nvmctrl.h sercom4.h sercom3.h tc6.h port.h dsu.h tc4.h wdt.h sercom5.h adc.h tc3.h tc0.h pm.h sysctrl.h tc7.h gclk.h tc5.h pac1.h sercom0.h
  group sam0/utils/cmsis/samd20/include/component
    ../../../../utils/cmsis/samd20/include/component/: wdt.h adc.h rtc.h dac.h dsu.h gclk.h evsys.h pac.h eic.h port.h sercom.h sysctrl.h pm.h tc.h nvmctrl.h ac.h
  group sam0/utils/cmsis/samd20/include/pio
    ../../../../utils/cmsis/samd20/include/pio/: samd20g16.h samd20e18.h samd20g18.h samd20e1f.h samd20e14.h samd20g18u.h samd20e15.h samd20j14.h samd20j17.h samd20j18.h samd20e17.h samd20g15.h samd20e16.h samd20j15.h samd20g17u.h samd20g17.h samd20j16.h samd20g14.h
  group sam0/utils/header_files
    ../../../../utils/header_files/: io.h
  group sam0/utils/preprocessor
    ../../../../utils/preprocessor/: mrecursion.h mrepeat.h tpaste.h preprocessor.h stringz.h
  group sam0/applications/spi_master_bootloader
    ../../: spi_master_bootloader.c
  group sam0/applications/spi_master_bootloader/samd20_xplained_pro
    ../: conf_board.h conf_bootloader.h conf_at45dbx.h conf_spi.h conf_clocks.h
  group sam0/applications/spi_master_bootloader/samd20_xplained_pro/iar
    ./: asf.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../common/boards/: board.h
