# IAR project low_power_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4C16C_0 Atmel ATSAM4C16C Core0
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4C_EK; ARM_MATH_CM4=true; __SAM4C16C_0__
  ICCARM.CCIncludePath2: ../../../../../common/services/serial/sam_uart; ..; ../../../../drivers/rstc; ../../../../utils/preprocessor; ../..; ../../../../drivers/pmc; ../../../../drivers/efc; ../../../../../common/services/serial; ../../../../drivers/gpbr; ../../../../utils/cmsis/sam4c/source/templates; ../../../../boards/sam4c_ek; ../../../../drivers/supc; ../../../../../common/utils; ../../../../drivers/wdt; ../../../../../common/services/clock; ../../../../boards; ../../../../../common/utils/stdio/stdio_serial; ../../../../drivers/uart; ../../../../utils; ../../../../utils/cmsis/sam4c/include; ../../../../utils/header_files; ../../../../../common/boards; ../../../../../common/services/ioport; ../../../../drivers/pio; ../../../../drivers/usart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4C_EK; ARM_MATH_CM4=true; __SAM4C16C_0__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: low_power_flash.bin
  ILINK.IlinkOutputFile: low_power_flash.out
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/sam4c/iar/sam4c16c_0_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/supc
    ../../../../drivers/supc/: supc.c supc.h
  group sam/drivers/usart
    ../../../../drivers/usart/: usart.c usart.h
  group sam/drivers/efc
    ../../../../drivers/efc/: efc.c efc.h
  group sam/drivers/pio
    ../../../../drivers/pio/: pio_handler.c pio.c pio.h pio_handler.h
  group sam/drivers/uart
    ../../../../drivers/uart/: uart.c uart.h
  group sam/drivers/pmc
    ../../../../drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/gpbr
    ../../../../drivers/gpbr/: gpbr.c gpbr.h
  group sam/drivers/wdt
    ../../../../drivers/wdt/: wdt.c wdt.h
  group sam/drivers/rstc
    ../../../../drivers/rstc/: rstc.c rstc.h
  group sam/drivers/rstc/example1
    ../../../../drivers/rstc/example1/: rstc_example1.h
  group sam/boards/sam4c_ek
    ../../../../boards/sam4c_ek/: init.c led.h sam4c_ek.h
  group sam/utils
    ../../../../utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4c/source/templates
    ../../../../utils/cmsis/sam4c/source/templates/: system_sam4c.c
  group sam/utils/cmsis/sam4c/source/templates/iar
    ../../../../utils/cmsis/sam4c/source/templates/iar/: startup_sam4c.c
  group sam/utils/cmsis/sam4c/include
    ../../../../utils/cmsis/sam4c/include/: sam4c16c_0.h system_sam4c.h sam4c32c_1.h sam4c32e_1.h sam4c8c_0.h sam4c32c_0.h sam4c8c_1.h sam4c32e_0.h sam4c16c_1.h sam4c.h
  group sam/utils/cmsis/sam4c/include/component
    ../../../../utils/cmsis/sam4c/include/component/: component_efc.h component_uart.h component_chipid.h component_spi.h component_cmcc.h component_gpbr.h component_supc.h component_pmc.h component_tc.h component_rtc.h component_slcdc.h component_adc.h component_smc.h component_matrix.h component_icm.h component_trng.h component_wdt.h component_rswdt.h component_aes.h component_ipc.h component_rtt.h component_pdc.h component_pio.h component_usart.h component_rstc.h component_twi.h component_pwm.h component_uotghs.h
  group sam/utils/cmsis/sam4c/include/instance
    ../../../../utils/cmsis/sam4c/include/instance/: instance_gpbr.h instance_tc1.h instance_rswdt.h instance_twi1.h instance_supc.h instance_smc0.h instance_pwm.h instance_ipc1.h instance_trng.h instance_uart1.h instance_cmcc1.h instance_wdt.h instance_rtt.h instance_usart4.h instance_piob.h instance_efc.h instance_tc0.h instance_spi1.h instance_efc0.h instance_aes.h instance_rtc.h instance_spi0.h instance_matrix1.h instance_usart3.h instance_usart1.h instance_pioa.h instance_efc1.h instance_pmc.h instance_pioc.h instance_rstc.h instance_ipc0.h instance_matrix0.h instance_usart2.h instance_slcdc.h instance_usart0.h instance_piod.h instance_chipid.h instance_icm.h instance_twi0.h instance_smc1.h instance_uotghs.h instance_adc.h instance_uart0.h instance_cmcc0.h
  group sam/utils/cmsis/sam4c/include/pio
    ../../../../utils/cmsis/sam4c/include/pio/: pio_sam4c16c.h pio_sam4c8c.h pio_sam4c32c.h pio_sam4c32e.h
  group sam/utils/header_files
    ../../../../utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../utils/preprocessor/: mrepeat.h tpaste.h preprocessor.h stringz.h
  group sam/applications/sam_low_power
    ../../: main.c
  group sam/applications/sam_low_power/sam4c16c_sam4c_ek
    ../: low_power_board.c conf_uart_serial.h conf_clock.h conf_board.h low_power_board.h
  group sam/applications/sam_low_power/sam4c16c_sam4c_ek/iar
    ./: asf.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/clock
    ../../../../../common/services/clock/: sysclk.h osc.h genclk.h pll.h
  group common/services/clock/sam4c
    ../../../../../common/services/clock/sam4c/: sysclk.c sysclk.h genclk.h pll.h osc.h
  group common/services/serial
    ../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../common/boards/: board.h
