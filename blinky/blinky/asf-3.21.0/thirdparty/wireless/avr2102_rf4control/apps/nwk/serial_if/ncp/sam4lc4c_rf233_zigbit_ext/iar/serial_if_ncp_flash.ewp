# IAR project serial_if_ncp_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4LC4C Atmel ATSAM4LC4C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ENABLE_STACK_NVM; BOARD=SAM4L_XPLAINED_PRO; CUSTOM_DEFAULT_TX_PWR; EXT_RF_FRONT_END_CTRL; SAL_TYPE=AT86RF2xx; NLDE_HANDLE; DISABLE_TSTAMP_IRQ=1; ANTENNA_DIVERSITY=0; _DEBUG_=0; __SAM4LC4C__; MAC_USER_BUILD_CONFIG; ENABLE_TRX_SRAM; RF4CE_SECURITY; RSSI_TO_LQI_MAPPING; ARM_MATH_CM4=true; PAL_USE_SPI_TRX=1; STB_ON_SAL; REDUCED_PARAM_CHECK; CHANNEL_AGILITY; PRIVATE_NIB; SIO_HUB; RF4CE_CALLBACK_PARAM; TAL_TYPE=AT86RF233; HIGHEST_STACK_LAYER=RF4CE; CUSTOM_PWR_TABLE; RF4CE_PLATFORM
  ICCARM.CCIncludePath2: ../../../../../../../../../common/services/serial/sam_uart; ../../../../../../../avr2025_mac/source/mac/inc; ../../../../../../../../../common/services/spi/sam_spi; ../../../../../../../avr2025_mac/source/pal/common/drivers/nvm; ../../../../../../../../../common/boards; ../../../../../../addons/serial_interface; ../../../../../../../../../sam/utils/preprocessor; ../../../../../../../avr2025_mac/source/pal/common_sw_timer; ../../../../../../../services/sal/inc; ../../../../../../include; ../../../../../../../avr2025_mac/source/resources/queue/inc; ../../../../../../../../../sam/utils/cmsis/sam4l/include; ../../../../../../../services/trx_access; ../../../../../../../avr2025_mac/include; ../../../../../../../../../sam/utils/cmsis/sam4l/source/templates; ../../../../../../../addons/sio2host/uart; ../../../../../../../avr2025_mac/source/stb/inc; ../../../../../../../../../common/services/serial; ../../../../../../../../../sam/drivers/spi; ../../../../../../../../../sam/boards; ../../../../../../../avr2025_mac/source/resources/buffer/inc; ../../../../../../../../../common/utils; ../../../../../../../avr2025_mac/source/tal/at86rf233/inc; ../../../../../../../../../sam/drivers/wdt; ../..; ../../../../../../../../../common/services/clock; ../../../../../../../services/common_hw_timer/sam; ..; ../../../../../../../../../common/utils/stdio/stdio_serial; ../../../../../../../services/common_hw_timer; ../../../../../../../avr2025_mac/source/tal/inc; ../../../../../../../avr2025_mac/source/pal; ../../../../../../lib/nwk/config; ../../../../../../../../../common/services/delay; ../../../../../../../../../sam/utils; ../../../../../../../../../sam/drivers/tc; ../../../../../../../../../common/services/spi; ../../../../../../../../../sam/utils/header_files; ../../../../../../../../../sam/drivers/flashcalw; ../../../../../../../../../sam/boards/sam4l_xplained_pro; ../../../../../../../../../common/services/ioport; ../../../../../../../../../sam/drivers/bpm; ../../../../../../../../../sam/drivers/usart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: serial_if_ncp_flash.bin
  ILINK.IlinkOutputFile: serial_if_ncp_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../sam/utils/linker_scripts/sam4l/sam4l4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/wireless/avr2102_rf4control/lib/nwk/atsam4lc4c/iar
    ../../../../../../lib/nwk/atsam4lc4c/iar/: librf4ce-nwk.a
  group thirdparty/wireless/avr2102_rf4control/lib/nwk/config
    ../../../../../../lib/nwk/config/: node_config.h
  group thirdparty/wireless/avr2102_rf4control/apps/nwk/serial_if
    ../../../: main.c
  group thirdparty/wireless/avr2102_rf4control/apps/nwk/serial_if/ncp
    ../../: app_config.h conf_common_sw_timer.h conf_trx_access.h
  group thirdparty/wireless/avr2102_rf4control/apps/nwk/serial_if/ncp/sam4lc4c_rf233_zigbit_ext
    ../: conf_sio2host.h conf_uart_serial.h conf_board.h conf_clock.h conf_spi_master.h conf_nvm.h conf_hw_timer.h
  group thirdparty/wireless/avr2102_rf4control/apps/nwk/serial_if/ncp/sam4lc4c_rf233_zigbit_ext/iar
    ./: asf.h
  group thirdparty/wireless/avr2102_rf4control/addons/serial_interface
    ../../../../../../addons/serial_interface/: serial_interface.c serial_interface.h
  group thirdparty/wireless/avr2102_rf4control/include
    ../../../../../../include/: nwk_msg_types.h mac_user_build_config.h zid_build_config.h nwk_internal.h gdp_config.h zid_adaptor.h nwk_msg_code.h rf4ce.h pb_pairing.h nwk_build_config.h zid.h zrc.h nwk_config.h vendor_data.h gdp.h zid_device.h
  group thirdparty/wireless/services/common_hw_timer
    ../../../../../../../services/common_hw_timer/: common_hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/sam
    ../../../../../../../services/common_hw_timer/sam/: hw_timer.c hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/sam/lib
    ../../../../../../../services/common_hw_timer/sam/lib/: sam4l_lib_hw_timer.a
  group thirdparty/wireless/services/trx_access
    ../../../../../../../services/trx_access/: trx_access.c trx_access.h
  group thirdparty/wireless/services/sal/at86rf2xx/src
    ../../../../../../../services/sal/at86rf2xx/src/: sal.c
  group thirdparty/wireless/services/sal/inc
    ../../../../../../../services/sal/inc/: sal_generic.h sal.h sal_types.h
  group thirdparty/wireless/avr2025_mac/source/mac/src
    ../../../../../../../avr2025_mac/source/mac/src/: mac_security.c mac_beacon.c mac_data_req.c mac_disassociate.c mac_pib.c mac_tx_coord_realignment_command.c mac_misc.c mac_process_tal_tx_frame_status.c mac_gts.c mac_process_beacon_frame.c mac_poll.c mac_rx_enable.c mac_mcps_data.c mac_data_extract_mhr.c mac_data_ind.c mac_scan.c mac.c mac_dispatcher.c mac_orphan.c mac_start.c mac_associate.c mac_sync.c
  group thirdparty/wireless/avr2025_mac/source/mac/inc
    ../../../../../../../avr2025_mac/source/mac/inc/: mac_config.h mac.h mac_msg_const.h mac_api.h mac_msg_types.h mac_msg_type_data_ind.h mac_internal.h mac_data_structures.h mac_security.h
  group thirdparty/wireless/avr2025_mac/source/tal/src
    ../../../../../../../avr2025_mac/source/tal/src/: tal_helper.c
  group thirdparty/wireless/avr2025_mac/source/tal/at86rf233/src
    ../../../../../../../avr2025_mac/source/tal/at86rf233/src/: tal.c tal_irq_handler.c tal_slotted_csma.c tal_rx_enable.c tal_init.c tal_pwr_mgmt.c tal_tx.c tal_rx.c tal_ed.c tal_pib.c
  group thirdparty/wireless/avr2025_mac/source/tal/at86rf233/inc
    ../../../../../../../avr2025_mac/source/tal/at86rf233/inc/: tal_slotted_csma.h tal_tx.h tal_irq_handler.h tal_constants.h tal_rx.h tal_config.h at86rf233.h tal_internal.h tal_pib.h
  group thirdparty/wireless/avr2025_mac/source/tal/inc
    ../../../../../../../avr2025_mac/source/tal/inc/: tal_types.h tal.h tal_generic.h tal_helper.h tal_timer_config.h
  group thirdparty/wireless/avr2025_mac/source/pal
    ../../../../../../../avr2025_mac/source/pal/: pal.c pal_generic.h pal.h
  group thirdparty/wireless/avr2025_mac/source/pal/common/drivers/nvm
    ../../../../../../../avr2025_mac/source/pal/common/drivers/nvm/: common_nvm.h
  group thirdparty/wireless/avr2025_mac/source/pal/common/drivers/nvm/sam
    ../../../../../../../avr2025_mac/source/pal/common/drivers/nvm/sam/: sam_nvm.c
  group thirdparty/wireless/avr2025_mac/source/pal/common_sw_timer
    ../../../../../../../avr2025_mac/source/pal/common_sw_timer/: common_sw_timer.c common_sw_timer.h
  group thirdparty/wireless/avr2025_mac/source/stb/src
    ../../../../../../../avr2025_mac/source/stb/src/: stb.c stb_help.c stb_armcrypto.c
  group thirdparty/wireless/avr2025_mac/source/stb/inc
    ../../../../../../../avr2025_mac/source/stb/inc/: stb_internal.h stb_generic.h stb_armcrypto.h stb.h
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/src
    ../../../../../../../avr2025_mac/source/resources/buffer/src/: bmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/inc
    ../../../../../../../avr2025_mac/source/resources/buffer/inc/: bmm.h
  group thirdparty/wireless/avr2025_mac/source/resources/queue/src
    ../../../../../../../avr2025_mac/source/resources/queue/src/: qmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/queue/inc
    ../../../../../../../avr2025_mac/source/resources/queue/inc/: qmm.h
  group thirdparty/wireless/avr2025_mac/include
    ../../../../../../../avr2025_mac/include/: ieee_const.h stack_config.h mac_build_config.h tal_build_config.h return_val.h avr2025_mac.h
  group thirdparty/wireless/addons/sio2host/uart
    ../../../../../../../addons/sio2host/uart/: sio2host.c sio2host.h
  group common/utils
    ../../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/delay
    ../../../../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/clock
    ../../../../../../../../../common/services/clock/: sysclk.h pll.h genclk.h dfll.h osc.h
  group common/services/clock/sam4l
    ../../../../../../../../../common/services/clock/sam4l/: dfll.c pll.c osc.c sysclk.c sysclk.h dfll.h osc.h genclk.h pll.h
  group common/services/spi
    ../../../../../../../../../common/services/spi/: spi_master.h
  group common/services/spi/sam_spi
    ../../../../../../../../../common/services/spi/sam_spi/: spi_master.c spi_master.h
  group common/services/serial
    ../../../../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../../../common/services/ioport/sam/: ioport_gpio.h
  group common/boards
    ../../../../../../../../../common/boards/: board.h
  group sam/drivers/spi
    ../../../../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/flashcalw
    ../../../../../../../../../sam/drivers/flashcalw/: flashcalw.c flashcalw.h
  group sam/drivers/usart
    ../../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/wdt
    ../../../../../../../../../sam/drivers/wdt/: wdt_sam4l.c wdt_sam4l.h
  group sam/drivers/bpm
    ../../../../../../../../../sam/drivers/bpm/: bpm.c bpm.h
  group sam/drivers/tc
    ../../../../../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/utils
    ../../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4l/source/templates
    ../../../../../../../../../sam/utils/cmsis/sam4l/source/templates/: system_sam4l.c exceptions.c system_sam4l.h exceptions.h
  group sam/utils/cmsis/sam4l/source/templates/iar
    ../../../../../../../../../sam/utils/cmsis/sam4l/source/templates/iar/: startup_sam4l.c
  group sam/utils/cmsis/sam4l/include
    ../../../../../../../../../sam/utils/cmsis/sam4l/include/: sam4ls2c.h sam4lc2b.h sam4ls2a.h sam4lc4b.h sam4l.h sam4ls8c.h sam4lc4a.h sam4lc2c.h sam4lc2a.h sam4lc4c.h sam4lc8b.h sam4ls8b.h sam4ls4b.h sam4lc8a.h sam4lc8c.h sam4ls2b.h sam4ls4a.h sam4ls4c.h sam4ls8a.h
  group sam/utils/cmsis/sam4l/include/instance
    ../../../../../../../../../sam/utils/cmsis/sam4l/include/instance/: instance_gpio.h instance_spi.h instance_pevc.h instance_twis1.h instance_usbc.h instance_hflashc.h instance_hcache.h instance_parc.h instance_iisc.h instance_gloc.h instance_pm.h instance_catb.h instance_crccu.h instance_adcife.h instance_twim1.h instance_twim2.h instance_bpm.h instance_twim3.h instance_trng.h instance_wdt.h instance_twis0.h instance_bscif.h instance_dacc.h instance_usart3.h instance_hmatrix.h instance_usart1.h instance_chipid.h instance_freqm.h instance_aesa.h instance_twim0.h instance_tc1.h instance_usart0.h instance_eic.h instance_abdacb.h instance_acifc.h instance_scif.h instance_pdca.h instance_ast.h instance_usart2.h instance_lcdca.h instance_smap.h instance_picouart.h instance_tc0.h
  group sam/utils/cmsis/sam4l/include/component
    ../../../../../../../../../sam/utils/cmsis/sam4l/include/component/: component_gloc.h component_hcache.h component_adcife.h component_smap.h component_usbc.h component_freqm.h component_gpio.h component_dacc.h component_wdt.h component_trng.h component_eic.h component_chipid.h component_usart.h component_lcdca.h component_iisc.h component_abdacb.h component_twis.h component_twim.h component_acifc.h component_picouart.h component_pevc.h component_scif.h component_parc.h component_hmatrixb.h component_tc.h component_ast.h component_flashcalw.h component_bscif.h component_catb.h component_pdca.h component_spi.h component_bpm.h component_crccu.h component_pm.h component_aesa.h
  group sam/utils/cmsis/sam4l/include/pio
    ../../../../../../../../../sam/utils/cmsis/sam4l/include/pio/: pio_sam4lc8c.h pio_sam4lc2b.h pio_sam4ls8c.h pio_sam4lc2a.h pio_sam4ls2b.h pio_sam4ls8b.h pio_sam4ls4a.h pio_sam4lc4a.h pio_sam4lc4b.h pio_sam4ls2c.h pio_sam4lc2c.h pio_sam4ls4c.h pio_sam4ls8a.h pio_sam4ls2a.h pio_sam4lc4c.h pio_sam4ls4b.h pio_sam4lc8a.h pio_sam4lc8b.h
  group sam/utils/header_files
    ../../../../../../../../../sam/utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../../../../../../sam/utils/preprocessor/: mrepeat.h preprocessor.h stringz.h tpaste.h
  group sam/boards/sam4l_xplained_pro
    ../../../../../../../../../sam/boards/sam4l_xplained_pro/: init.c sam4l_xplained_pro.h led.h
