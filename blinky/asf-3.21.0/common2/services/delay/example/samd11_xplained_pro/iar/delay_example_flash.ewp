# IAR project delay_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD11D14AM Atmel ATSAMD11D14AM
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SYSTICK_MODE; BOARD=SAMD11_XPLAINED_PRO; __SAMD11D14AM__; ARM_MATH_CM0=true
  ICCARM.CCIncludePath2: ../../../../../../sam0/drivers/port; ../../../../../../sam0/drivers/system/reset; ../../../../../../sam0/utils/preprocessor; ../../..; ../../../../../../sam0/utils; ../../../../../../sam0/boards/samd11_xplained_pro; ../../../../../../sam0/drivers/system/power; ../../../../../../sam0/boards; ../../../../../../sam0/drivers/system/interrupt/system_interrupt_samd10_d11; ../../../../../../common/utils; ../../../../../../sam0/utils/cmsis/samd11/source; ../../../../../../sam0/drivers/system/interrupt; ../../../../../../sam0/drivers/system/clock/clock_samd10_d11; ../../../../../../sam0/drivers/system/power/power_sam_d_r; ../../../../../../sam0/drivers/system/reset/reset_sam_d_r; ../../../../../../sam0/utils/cmsis/samd11/include; ../../../sam0; ..; ../../../../../../common/boards; ../../../../../../sam0/drivers/system/pinmux; ../../../../../../sam0/drivers/system; ../../../../../../sam0/utils/header_files; ../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: delay_example_flash.bin
  ILINK.IlinkOutputFile: delay_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam0/utils/linker_scripts/samd11/iar/samd11d14am_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/system
    ../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/interrupt
    ../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd10_d11
    ../../../../../../sam0/drivers/system/interrupt/system_interrupt_samd10_d11/: system_interrupt_features.h
  group sam0/drivers/system/clock
    ../../../../../../sam0/drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd10_d11
    ../../../../../../sam0/drivers/system/clock/clock_samd10_d11/: gclk.c clock.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/pinmux
    ../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/reset/reset_sam_d_r
    ../../../../../../sam0/drivers/system/reset/reset_sam_d_r/: reset.h
  group sam0/drivers/system/power/power_sam_d_r
    ../../../../../../sam0/drivers/system/power/power_sam_d_r/: power.h
  group sam0/drivers/port
    ../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/utils
    ../../../../../../sam0/utils/: status_codes.h compiler.h
  group sam0/utils/cmsis/samd11/source
    ../../../../../../sam0/utils/cmsis/samd11/source/: system_samd11.c system_samd11.h
  group sam0/utils/cmsis/samd11/source/iar
    ../../../../../../sam0/utils/cmsis/samd11/source/iar/: startup_samd11.c
  group sam0/utils/cmsis/samd11/include
    ../../../../../../sam0/utils/cmsis/samd11/include/: samd11c14a.h samd11d14am.h samd11.h samd11d14as.h
  group sam0/utils/cmsis/samd11/include/component
    ../../../../../../sam0/utils/cmsis/samd11/include/component/: eic.h dsu.h port.h usb.h pm.h ac.h wdt.h adc.h nvmctrl.h sysctrl.h tcc.h pac.h tc.h mtb.h dac.h rtc.h sercom.h gclk.h dmac.h evsys.h
  group sam0/utils/cmsis/samd11/include/instance
    ../../../../../../sam0/utils/cmsis/samd11/include/instance/: pac0.h eic.h tcc0.h mtb.h pac1.h dsu.h sercom2.h evsys.h pm.h dmac.h wdt.h pac2.h port.h tc2.h dac.h nvmctrl.h sysctrl.h sercom1.h ac.h gclk.h usb.h tc1.h adc.h rtc.h sercom0.h
  group sam0/utils/cmsis/samd11/include/pio
    ../../../../../../sam0/utils/cmsis/samd11/include/pio/: samd11d14am.h samd11d14as.h samd11c14a.h
  group sam0/utils/preprocessor
    ../../../../../../sam0/utils/preprocessor/: tpaste.h stringz.h mrepeat.h mrecursion.h preprocessor.h
  group sam0/utils/header_files
    ../../../../../../sam0/utils/header_files/: io.h
  group sam0/boards/samd11_xplained_pro
    ../../../../../../sam0/boards/samd11_xplained_pro/: board_init.c samd11_xplained_pro.h
  group common2/services/delay
    ../../../: delay.h
  group common2/services/delay/example
    ../../: delay_example.c
  group common2/services/delay/example/samd11_xplained_pro
    ../: conf_clocks.h conf_board.h
  group common2/services/delay/example/samd11_xplained_pro/iar
    ./: asf.h
  group common2/services/delay/sam0
    ../../../sam0/: systick_counter.c systick_counter.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../common/boards/: board.h
