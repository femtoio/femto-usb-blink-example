# IAR project at45dbx_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD20J18 Atmel ATSAMD20J18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM0=true; SPI_CALLBACK_MODE=false; BOARD=SAMD20_XPLAINED_PRO; __SAMD20J18__
  ICCARM.CCIncludePath2: ../../../../../../../../sam0/drivers/system/clock/clock_samd20; ../../../../../../../../sam0/drivers/port; ../../../../../../../../sam0/drivers/system/reset; ../../../../../../../../sam0/utils/preprocessor; ../../../../../../../../sam0/boards/samd20_xplained_pro; ../../../../../../../../sam0/utils/cmsis/samd20/source; ..; ../../../../../../../../sam0/drivers/sercom/spi; ../../../../../../../../sam0/utils; ../../../../../../../../sam0/drivers/sercom; ../../../../../../../../sam0/drivers/system/power; ../../../../../../../../sam0/boards; ../../..; ../../../../../../../../common/utils; ../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samd20; ../../../../../../../../sam0/drivers/system/interrupt; ../../../../../../../../sam0/drivers/system/power/power_sam_d_r; ../../../../../../../../sam0/drivers/system/reset/reset_sam_d_r; ../../../../../../../../common/boards; ../../../../../../../../sam0/utils/cmsis/samd20/include; ../../../../../../../../sam0/drivers/system/pinmux; ../../../../../../../../sam0/drivers/system; ../../../../../../../../sam0/utils/header_files; ../../../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: at45dbx_example_flash.bin
  ILINK.IlinkOutputFile: at45dbx_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../sam0/utils/linker_scripts/samd20/iar/samd20j18_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/utils
    ../../../../../../../../sam0/utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samd20/source
    ../../../../../../../../sam0/utils/cmsis/samd20/source/: system_samd20.c system_samd20.h
  group sam0/utils/cmsis/samd20/source/iar
    ../../../../../../../../sam0/utils/cmsis/samd20/source/iar/: startup_samd20.c
  group sam0/utils/cmsis/samd20/include
    ../../../../../../../../sam0/utils/cmsis/samd20/include/: samd20g18.h samd20g16.h samd20g18u.h samd20j18.h samd20j14.h samd20g14.h samd20j17.h samd20e16.h samd20e14.h samd20g15.h samd20g17u.h samd20j16.h samd20e17.h samd20e15.h samd20.h samd20e18.h samd20j15.h samd20g17.h
  group sam0/utils/cmsis/samd20/include/component
    ../../../../../../../../sam0/utils/cmsis/samd20/include/component/: eic.h adc.h sysctrl.h nvmctrl.h pm.h dsu.h sercom.h wdt.h dac.h ac.h tc.h rtc.h gclk.h pac.h evsys.h port.h
  group sam0/utils/cmsis/samd20/include/instance
    ../../../../../../../../sam0/utils/cmsis/samd20/include/instance/: eic.h nvmctrl.h port.h pac2.h evsys.h dac.h sysctrl.h pac0.h sercom0.h sercom2.h tc2.h rtc.h tc0.h sercom4.h gclk.h sercom1.h tc5.h tc6.h ac.h tc3.h tc4.h adc.h tc1.h dsu.h sercom3.h sercom5.h pac1.h pm.h wdt.h tc7.h
  group sam0/utils/cmsis/samd20/include/pio
    ../../../../../../../../sam0/utils/cmsis/samd20/include/pio/: samd20e14.h samd20j15.h samd20g17u.h samd20g18u.h samd20e18.h samd20g17.h samd20g18.h samd20g15.h samd20e16.h samd20j18.h samd20j16.h samd20j14.h samd20g16.h samd20g14.h samd20e1f.h samd20e17.h samd20e15.h samd20j17.h
  group sam0/utils/header_files
    ../../../../../../../../sam0/utils/header_files/: io.h
  group sam0/utils/preprocessor
    ../../../../../../../../sam0/utils/preprocessor/: preprocessor.h tpaste.h stringz.h mrepeat.h mrecursion.h
  group sam0/drivers/sercom
    ../../../../../../../../sam0/drivers/sercom/: sercom.c sercom.h sercom_pinout.h
  group sam0/drivers/sercom/spi
    ../../../../../../../../sam0/drivers/sercom/spi/: spi.c spi.h
  group sam0/drivers/sercom/spi/quick_start_master
    ../../../../../../../../sam0/drivers/sercom/spi/quick_start_master/: qs_spi_master_basic.h
  group sam0/drivers/sercom/spi/quick_start_dma
    ../../../../../../../../sam0/drivers/sercom/spi/quick_start_dma/: qs_spi_dma_use.h
  group sam0/drivers/sercom/spi/quick_start_slave
    ../../../../../../../../sam0/drivers/sercom/spi/quick_start_slave/: qs_spi_slave_basic.h
  group sam0/drivers/system
    ../../../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/interrupt
    ../../../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd20
    ../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samd20/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/clock
    ../../../../../../../../sam0/drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd20
    ../../../../../../../../sam0/drivers/system/clock/clock_samd20/: clock.c gclk.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/power/power_sam_d_r
    ../../../../../../../../sam0/drivers/system/power/power_sam_d_r/: power.h
  group sam0/drivers/system/reset/reset_sam_d_r
    ../../../../../../../../sam0/drivers/system/reset/reset_sam_d_r/: reset.h
  group sam0/drivers/port
    ../../../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/boards/samd20_xplained_pro
    ../../../../../../../../sam0/boards/samd20_xplained_pro/: board_init.c samd20_xplained_pro.h
  group common2/components/memory/data_flash/at45dbx
    ../../../: at45dbx.c at45dbx.h at45dbx_hal_spi.h
  group common2/components/memory/data_flash/at45dbx/example
    ../../: at45dbx_example.c
  group common2/components/memory/data_flash/at45dbx/example/samd20_xplained_pro
    ../: conf_data_flash_example.h conf_board.h conf_at45dbx.h conf_spi.h conf_clocks.h
  group common2/components/memory/data_flash/at45dbx/example/samd20_xplained_pro/iar
    ./: asf.h
  group common/utils
    ../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
