# IAR project apps_wsndemo_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4LC4C Atmel ATSAM4LC4C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM4LC4C__; PHY_AT86RF212B; SAL_TYPE=AT86RF2xx; ARM_MATH_CM4=true; BOARD=SAM4L_XPLAINED_PRO
  ICCARM.CCIncludePath2: ../../../../../../../common/services/serial/sam_uart; ../../../../../../../common/services/spi/sam_spi; ../../../../../../../common/boards; ../../../../../../../sam/utils/preprocessor; ../../../../source/phy/at86rf212b/inc; ../../../../../services/sal/inc; ../../../../../../../sam/utils/cmsis/sam4l/include; ../../../../../services/trx_access; ../../../../../../../sam/utils/cmsis/sam4l/source/templates; ../../../../../../../common/services/serial; ../../../../../../../sam/drivers/ast; ..; ../../../../../../../sam/boards; ../../../../../../../common/services/sleepmgr; ../../../../../../../common/utils; ../../../../../services/sleep_mgr; ../../../../../../../sam/drivers/spi; ../../../../../../../sam/drivers/wdt; ../../../../source/nwk/inc; ../../../../../../../common/services/clock; ../../../../../services/common_hw_timer/sam; ../../../../../../../common/utils/stdio/stdio_serial; ../../../../source/sys/inc; ../../../../../services/common_hw_timer; ../../../../../addons/sio2host/uart; ../../../../../../../common/services/delay; ../../../../../../../sam/utils; ../..; ../../../../../../../sam/drivers/tc; ../../../../../../../sam/drivers/usart; ../../../../../../../sam/utils/header_files; ../../../../../../../sam/drivers/flashcalw; ../../../../../../../sam/boards/sam4l_xplained_pro; ../../../../../../../common/services/ioport; ../../../../../../../sam/drivers/bpm; ../../../../../../../common/services/spi; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: apps_wsndemo_flash.bin
  ILINK.IlinkOutputFile: apps_wsndemo_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../sam/utils/linker_scripts/sam4l/sam4l4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/wireless/services/common_hw_timer
    ../../../../../services/common_hw_timer/: common_hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/sam
    ../../../../../services/common_hw_timer/sam/: hw_timer.c hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/sam/lib
    ../../../../../services/common_hw_timer/sam/lib/: sam4l_lib_hw_timer.a
  group thirdparty/wireless/services/trx_access
    ../../../../../services/trx_access/: trx_access.c trx_access.h
  group thirdparty/wireless/services/sleep_mgr
    ../../../../../services/sleep_mgr/: sleep_mgr.h
  group thirdparty/wireless/services/sleep_mgr/sam4l
    ../../../../../services/sleep_mgr/sam4l/: sleep_mgr.c
  group thirdparty/wireless/services/sal/at86rf2xx/src
    ../../../../../services/sal/at86rf2xx/src/: sal.c
  group thirdparty/wireless/services/sal/inc
    ../../../../../services/sal/inc/: sal_generic.h sal.h sal_types.h
  group thirdparty/wireless/avr2130_lwmesh/source/nwk/src
    ../../../../source/nwk/src/: nwkFrame.c nwkRoute.c nwkGroup.c nwk.c nwkDataReq.c nwkTx.c nwkSecurity.c nwkRouteDiscovery.c nwkRx.c
  group thirdparty/wireless/avr2130_lwmesh/source/nwk/inc
    ../../../../source/nwk/inc/: nwkDataReq.h nwkCommand.h nwkRx.h nwkRoute.h nwkTx.h nwk.h nwkGroup.h nwkSecurity.h nwkFrame.h nwkRouteDiscovery.h
  group thirdparty/wireless/avr2130_lwmesh/source/sys/src
    ../../../../source/sys/src/: sysEncrypt.c sys.c sysTimer.c
  group thirdparty/wireless/avr2130_lwmesh/source/sys/inc
    ../../../../source/sys/inc/: sys.h sysConfig.h sysTimer.h sysEncrypt.h
  group thirdparty/wireless/avr2130_lwmesh/source/phy/at86rf212b/src
    ../../../../source/phy/at86rf212b/src/: phy.c
  group thirdparty/wireless/avr2130_lwmesh/source/phy/at86rf212b/inc
    ../../../../source/phy/at86rf212b/inc/: at86rf212b.h phy.h
  group thirdparty/wireless/avr2130_lwmesh/apps/wsndemo
    ../../: wsndemo.c commands.c main.c wsndemo.h config.h commands.h
  group thirdparty/wireless/avr2130_lwmesh/apps/wsndemo/sam4lc4c_rf212b_zigbit_ext
    ../: conf_trx_access.h conf_sio2host.h conf_ast.h conf_uart_serial.h conf_clock.h conf_board.h conf_spi_master.h conf_sleepmgr.h conf_hw_timer.h
  group thirdparty/wireless/avr2130_lwmesh/apps/wsndemo/sam4lc4c_rf212b_zigbit_ext/iar
    ./: asf.h
  group thirdparty/wireless/addons/sio2host/uart
    ../../../../../addons/sio2host/uart/: sio2host.c sio2host.h
  group sam/utils
    ../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4l/source/templates
    ../../../../../../../sam/utils/cmsis/sam4l/source/templates/: system_sam4l.c exceptions.c exceptions.h system_sam4l.h
  group sam/utils/cmsis/sam4l/source/templates/iar
    ../../../../../../../sam/utils/cmsis/sam4l/source/templates/iar/: startup_sam4l.c
  group sam/utils/cmsis/sam4l/include
    ../../../../../../../sam/utils/cmsis/sam4l/include/: sam4ls8a.h sam4ls4a.h sam4ls8c.h sam4lc8a.h sam4l.h sam4lc4a.h sam4ls2b.h sam4ls4b.h sam4lc2b.h sam4lc8b.h sam4ls2a.h sam4ls2c.h sam4lc2c.h sam4lc2a.h sam4lc8c.h sam4lc4c.h sam4ls4c.h sam4lc4b.h sam4ls8b.h
  group sam/utils/cmsis/sam4l/include/component
    ../../../../../../../sam/utils/cmsis/sam4l/include/component/: component_abdacb.h component_pm.h component_hcache.h component_scif.h component_eic.h component_picouart.h component_aesa.h component_freqm.h component_twis.h component_twim.h component_trng.h component_gloc.h component_chipid.h component_pdca.h component_smap.h component_tc.h component_ast.h component_wdt.h component_gpio.h component_hmatrixb.h component_iisc.h component_crccu.h component_dacc.h component_parc.h component_bpm.h component_spi.h component_lcdca.h component_usbc.h component_adcife.h component_acifc.h component_usart.h component_pevc.h component_catb.h component_flashcalw.h component_bscif.h
  group sam/utils/cmsis/sam4l/include/instance
    ../../../../../../../sam/utils/cmsis/sam4l/include/instance/: instance_pm.h instance_iisc.h instance_chipid.h instance_crccu.h instance_gpio.h instance_wdt.h instance_freqm.h instance_twis1.h instance_dacc.h instance_pdca.h instance_aesa.h instance_usart2.h instance_twis0.h instance_picouart.h instance_parc.h instance_abdacb.h instance_trng.h instance_bpm.h instance_twim3.h instance_usart1.h instance_usbc.h instance_hmatrix.h instance_usart3.h instance_twim1.h instance_scif.h instance_adcife.h instance_eic.h instance_catb.h instance_tc1.h instance_pevc.h instance_ast.h instance_twim2.h instance_hcache.h instance_twim0.h instance_gloc.h instance_usart0.h instance_lcdca.h instance_hflashc.h instance_spi.h instance_acifc.h instance_bscif.h instance_tc0.h instance_smap.h
  group sam/utils/cmsis/sam4l/include/pio
    ../../../../../../../sam/utils/cmsis/sam4l/include/pio/: pio_sam4ls8a.h pio_sam4ls8c.h pio_sam4lc4c.h pio_sam4lc2b.h pio_sam4lc2a.h pio_sam4lc8c.h pio_sam4ls4c.h pio_sam4ls4a.h pio_sam4lc8b.h pio_sam4ls2a.h pio_sam4lc2c.h pio_sam4ls2b.h pio_sam4lc8a.h pio_sam4lc4b.h pio_sam4ls4b.h pio_sam4ls8b.h pio_sam4ls2c.h pio_sam4lc4a.h
  group sam/utils/preprocessor
    ../../../../../../../sam/utils/preprocessor/: mrepeat.h stringz.h tpaste.h preprocessor.h
  group sam/utils/header_files
    ../../../../../../../sam/utils/header_files/: io.h
  group sam/drivers/bpm
    ../../../../../../../sam/drivers/bpm/: bpm.c bpm.h
  group sam/drivers/tc
    ../../../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/drivers/spi
    ../../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/usart
    ../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/wdt
    ../../../../../../../sam/drivers/wdt/: wdt_sam4l.c wdt_sam4l.h
  group sam/drivers/ast
    ../../../../../../../sam/drivers/ast/: ast.c ast.h
  group sam/drivers/ast/example1
    ../../../../../../../sam/drivers/ast/example1/: ast_example1.h
  group sam/drivers/ast/example2
    ../../../../../../../sam/drivers/ast/example2/: ast_example2.h
  group sam/drivers/flashcalw
    ../../../../../../../sam/drivers/flashcalw/: flashcalw.c flashcalw.h
  group sam/boards/sam4l_xplained_pro
    ../../../../../../../sam/boards/sam4l_xplained_pro/: init.c led.h sam4l_xplained_pro.h
  group common/utils
    ../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/serial
    ../../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/spi
    ../../../../../../../common/services/spi/: spi_master.h
  group common/services/spi/sam_spi
    ../../../../../../../common/services/spi/sam_spi/: spi_master.c spi_master.h
  group common/services/clock
    ../../../../../../../common/services/clock/: sysclk.h osc.h genclk.h pll.h dfll.h
  group common/services/clock/sam4l
    ../../../../../../../common/services/clock/sam4l/: osc.c pll.c sysclk.c dfll.c sysclk.h osc.h pll.h dfll.h genclk.h
  group common/services/sleepmgr
    ../../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam4l
    ../../../../../../../common/services/sleepmgr/sam4l/: sleepmgr.c sleepmgr.h
  group common/services/delay
    ../../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/ioport
    ../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../common/services/ioport/sam/: ioport_gpio.h
  group common/boards
    ../../../../../../../common/boards/: board.h
